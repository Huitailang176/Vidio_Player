# Keil uVision project mp3_avi_nes_pic.uvprojx, settings and files
target pro_mp3_avi_nes_pic (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mp3_avi_nes_pic +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu
  c include: ..\app;..\board_dev;..\board_dev\lcd;..\board_dev\lcd_smart;..\audio_card;..\hardware;..\libc;..\project;..\start_menu;..\fatfs;..\fatfs\src;..\stm32f4xx_core;..\stm32f4xx_fwlib;..\stm32f4xx_fwlib\inc;..\system;..\media;..\media\picture;..\media\picture\TJPGD;..\media\audio;..\media\audio\helix;..\media\video;..\media\video\stream_decode;..\media\video\libmjpeg;..\media\nes;..\media\nes\libnes
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x5000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: kfifo.c my_malloc.c my_printf.c share.c
  group libc
    ../libc/: ctype.c stdio.c stdlib.c string.c time.c
  group project
    ./: main.c user_task.c user_tcb_v3.c
  group start_menu
    ../start_menu/: button_menu.c dir_list.c run_app.c
  group fatfs
    ../fatfs/: fs_app_v2.c myfat.c
    ../fatfs/src/: diskio.c ff.c
    ../fatfs/src/option/: cc936.c
  group board_dev
    ../board_dev/: key.c led.c sdio_sdcard_v5.c spi_flash_v4.c
    ../board_dev/lcd/: lcd_app_v2.c lcd_drv_fsmc407_v6.c
    ../board_dev/lcd_smart/: lcd_button.c lcd_list.c
  group audio_card
    ../audio_card/: audio_card.c i2s.c
  group hardware
    ../hardware/: flash.c fsmc.c rtc_v2.c sdio_v3.c spi_v3.c uart.c
  group system
    ../system/: cpu_related_v3.c systick.c cpu_related_a.asm
  group stm32f4xx_core
    ../stm32f4xx_core/: startup_stm32f40_41xxx.s
  group stm32f4xx_fwlib
    ../stm32f4xx_fwlib/: stm32f4xx_it.c system_stm32f4xx.c
    ../stm32f4xx_fwlib/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group media
    ../media/: media_timer_v2.c
  group media/picture
    ../media/picture/: bmp_codec.c ico_decode.c jpg_dec.c pic_display.c
  group media/picture/tjpgd
    ../media/picture/TJPGD/: tjpgd.c
  group media/audio
    ../media/audio/: audio_decode_support.c audio_player.c audio_player_ui.c libaudio_decode_stm32f407_v3_20211106.lib
  group media/audio/libhelix
    ../media/audio/helix/: helix_support.c libhelix_stm32f407.lib
  group media/video
    ../media/video/: video_player.c video_support.c
  group media/video/stream_decode
    ../media/video/stream_decode/: dec_mjpeg.c dec_mp3.c parse_avi.c video_app.c
  group media/video/libmjpeg
    ../media/video/libmjpeg/: jaricom.c jcomapi.c jdapimin.c jdapistd.c jdarith.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jerror.c jidctflt.c jidctfst.c jidctint.c jmemmgr.c jmemnobs.c jquant1.c jquant2.c jutils.c wrppm.c
  group media/nes
    ../media/nes/: gamepad.c nes_emulator.c nes_game_support.c
  group media/nes/libnes
    ../media/nes/libnes/: libnes_game_stm32f407_v6_320x240.lib
